# Keil uVision project STM32F103_Base32.uvprojx, settings and files
target EXAMPLE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_Base32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\02_Core;.\03_MCU;.\04_Driver;.\05_App;.\06_Soft;.\07_Source;.\RTE\Device\STM32F103C8
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group 01_Doc
    ./: A  0
  group 02_Core
    ./02_Core/: core_cm3.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h
  group 03_MCU
    ./03_MCU/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h stm32f10x_it.c stm32f10x_it.h
  group 04_Driver
    ./04_Driver/: misc.h stm32f10x_flash.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_spi.c stm32f10x_usart.c
  group 05_App
    ./05_App/: App.c App.h DipSwitch.c Cc1101.c Cc1101.h Cc1101Regs.h OLEDI2C.c OLEDI2C.h UwbParser.c UwbParser.h UwbSerial.c UwbSerial.h
  group 06_Soft
    ./06_Soft/: delay.c delay.h PositionSolver.c
  group 07_Source
    ./07_Source/: includes.h main.c
software components: Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1
